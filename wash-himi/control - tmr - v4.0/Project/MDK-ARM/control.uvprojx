# Keil uVision project control.uvprojx, settings and files
target control (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USART +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\STM32F10x_StdPeriph_Driver\src;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\inc;..\..\User\stepper;..\..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ./: ReadMe.txt
    ../src/: main.c delay.c bsp_motor_init.c bsp_key.c motor_control.c usart.c
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_sdio.c stm32f10x_flash.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_i2c.c stm32f10x_rtc.c stm32f10x_spi.c
  group CMSIS
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Startup
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
software components: CMSIS:CORE 5.4.0
